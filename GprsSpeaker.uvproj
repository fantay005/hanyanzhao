# Keil uVision project GprsSpeaker.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GprsSpeaker
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32100E_EVAL,inline=__inline
  c include: .\freertos\include;.\src;.\freertos\portable\RVDS\ARM_CM3;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SRC
    ./src/: main.c STM32F10x.s fputc.c cortexm3_macro_rvds.s gsm.c xfs.c mp3.c tim.c soundcontrol.c sms.c protocol.c fsmc_nor.c norflash.c
    ./: rtc.c
  group FreeRTOS
    ./freertos/: croutine.c list.c queue.c tasks.c timers.c
    ./freertos/portable/RVDS/ARM_CM3/: port.c
    ./freertos/portable/MemMang/: heap_4.c
  group STM32Lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
